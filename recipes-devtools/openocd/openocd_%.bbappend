EXTRA_OECONF_append += " --enable-imx_gpio"
PACKAGECONFIG_append = " sysfsgpio"