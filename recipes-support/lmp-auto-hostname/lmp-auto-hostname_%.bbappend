LMP_HOSTNAME_MACHINE:lmp-base ?= "dev-${MACHINE}"
