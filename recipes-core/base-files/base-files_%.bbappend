FILESEXTRAPATHS:prepend:lmp-base := "${THISDIR}/${PN}:"
