PACKAGECONFIG:append = " aklite-offline"

BRANCH:lmp = "v91"
SRCREV:lmp = "305682ab053e199d7c5a527a36213eaea3a26148"
