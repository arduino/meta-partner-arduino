SRC_URI = " \
    git://github.com/opencontainers/runc;protocol=https;branch=release-1.0 \
    file://0001-Makefile-respect-GOBUILDFLAGS-for-runc-and-remove-re.patch \
    "
